# Keil uVision project Lab5.uvprojx, settings and files
target Lab5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s Lab5.c Transmitter.c Receiver.c
    ../inc/: Texas.c Timer0A.c Timer1A.c ST7735.c PLL.c dsp.c TLV5616.c
software components: CMSIS:CORE 5.3.0
